# Repository skiselev/omega

File README.md:

# Omega
Omega Home Computer

[Lea este documento en español](README_es.md)

## Introduction
This project is an open source implementation of an MSX2 compatible computer. The project is built using a combination of 1980's era components - Z80 CPU, V9958 VDP, AY-3-8910/YM2149F PSG, 8255 PPI, 7400-series logic, and some newer components, such as 512 KiB SRAM and 512 KiB Flash ROM and a few simple programmable logic devices (ATF16V8B SPLDs).

## Status
* The project is completed, tested and works properly
* It is recommended to use the latest revision of the PCBs

## Documentation

[Keyboard](Keyboard.md)

[Main Board](Mainboard.md)

[Enclosure](Enclosure.md)

## KiCad design Mainboard/KiCad/Omega-Mainboard.kicad_pcb

Parts:
HOLE1, HOLE2, HOLE3, HOLE4, HOLE5, HOLE6, HOLE7, HOLE8, HOLE9, HOLE10, HOLE11: HOLE; Hole_3mm
J1: 5V; Conn_Power_Jack_Circular_Pads
J10: POWER; Conn_Friction_Lock_8P_2.54mm

Connections:
GND: HOLE1.1, HOLE2.1, HOLE3.1, HOLE4.1, HOLE5.1, HOLE6.1, HOLE7.1, HOLE8.1, HOLE9.1, HOLE10.1, HOLE11.1, J1.2, J1.3, J10.1, J10.2, J10.3; also elsewhere on the board
VCC: J1.1, J10.4, J10.5, J10.6; also elsewhere on the board
VDD: J10.7; also elsewhere on the board
VSS: J10.8; also elsewhere on the board

Parts:
C51, C52, C53, C54, C55, C56: 0.1uF; Cap_Cer_508
C59, C60, C61, C62, C63, C64: 220uF; Cap_Elec_Radial_10mm
C77: 10uF; Cap_Elec_Radial_5mm
C82, C83, C84: 330pF; Cap_Cer_508
C85: 47pF; Cap_Cer_508
C89, C90: 30pF; C_Trim_Murata
C91: 27pF; Cap_Cer_508
C92, C93: 22pF; Cap_Cer_508
C94: 4.7pF; Cap_Cer_508
J2: Composite; Conn_RCA_Right
J4: S-VIDEO; Conn_Mini_DIN_4pin
J5: RGB; Conn_DIN_8pin
J14: CBUS; Conn_Pin_Header_13x1_2.54mm
JP3, JP4: V9938/V9958; Conn_Pin_Header_3x1_2.54mm
JP5, JP6: NTSC/PAL; Conn_Pin_Header_3x1_2.54mm
L1: 68uH; Res_762
Q2: PN2907A; Transistor_TO92_EBC_254
R1: 1M; Res_762
R2: 470k; Res_762
R7: 47k; Res_762
R9: 20k; Res_762
R14: 10k; Res_762
R25: 2.2k; Res_762
R27, R28, R30, R33: 1k; Res_762
R35: 180; Res_762
R36: 120; Res_762
R37, R38, R39, R40: 100; Res_762
R43, R44, R45, R46, R47, R48: 75; Res_762
RR2, RR3: 10k; Conn_SIL10
RR9: 470; Conn_SIL6
U3: V9938/V9958; IC_SDIP64_600
U8, U9, U10, U11: D41464; IC_DIP18_300
U39: 74AHCT32; IC_DIP14_300
U43: 74HCT04; IC_DIP14_300
U47: CXA1645; IC_DIP24_400
Y1: 21.477270MHz; Crystal_HC-49U_Vert
Y3: 4.433618MHz; Crystal_HC-49U_Vert

Connections:
/A0: U3.29 (MODE0); also elsewhere on the board
/A1: U3.28 (MODE1); also elsewhere on the board
/AUDIO: J5.2; also elsewhere on the board
/CLK: U3.8 (CPUCLK), U39.4, U39.5; also elsewhere on the board
/D0: U3.40 (CD0); also elsewhere on the board
/D1: U3.39 (CD1); also elsewhere on the board
/D2: U3.38 (CD2); also elsewhere on the board
/D3: U3.37 (CD3); also elsewhere on the board
/D4: U3.36 (CD4); also elsewhere on the board
/D5: U3.35 (CD5); also elsewhere on the board
/D6: U3.34 (CD6); also elsewhere on the board
/D7: U3.32 (CD7); also elsewhere on the board
/VDP/AV: J5.3, R14.2, R33.1
/VDP/BLUE: C53.1, C84.1, RR9.6, U3.24 (B)
/VDP/BOUT: C64.2, J5.8
/VDP/CB0: J14.12, RR2.6, U3.19 (C0)
/VDP/CB1: J14.11, RR2.5, U3.18 (C1)
/VDP/CB2: J14.10, RR2.4, U3.17 (C2)
/VDP/CB3: J14.9, RR2.3, U3.16 (C3)
/VDP/CB4: J14.8, RR2.2, U3.15 (C4)
/VDP/CB5: J14.7, RR3.10, U3.14 (C5)
/VDP/CB6: J14.6, RR3.9, U3.13 (C6)
/VDP/CB7: J14.5, RR3.8, U3.12 (C7)
/VDP/CBDR: J14.4, U3.11 (CBDR)
/VDP/CHROMA: C60.2, J4.4
/VDP/COMP: C59.2, J2.1 (In), J5.4
/VDP/CSYNC: R27.2, U3.6 (CSYNC)
/VDP/GOUT: C63.2, J5.7
/VDP/GREEN: C52.1, C83.1, RR9.4, U3.22 (G)
/VDP/HSYNC: RR9.2, U3.5 (HSYNC)
/VDP/LUMA: C61.2, J4.3
/VDP/PAL_CLK: JP6.3, U43.4
/VDP/RED: C51.1, C82.1, RR9.5, U3.23 (R)
/VDP/ROUT: C62.2, J5.6
/VDP/SYNCIN: C85.1, JP4.2, U47.10 (SYNCIN)
/VDP/VA0: U3.49 (AD0), U8.14, U9.14, U10.14, U11.14
/VDP/VA1: U3.50 (AD1), U8.13, U9.13, U10.13, U11.13
/VDP/VA2: U3.51 (AD2), U8.12, U9.12, U10.12, U11.12
/VDP/VA3: U3.52 (AD3), U8.11, U9.11, U10.11, U11.11
/VDP/VA4: U3.53 (AD4), U8.8, U9.8, U10.8, U11.8
/VDP/VA5: U3.54 (AD5), U8.7, U9.7, U10.7, U11.7
/VDP/VA6: U3.55 (AD6), U8.6, U9.6, U10.6, U11.6
/VDP/VA7: U3.56 (AD7), U8.10, U9.10, U10.10, U11.10
/VDP/VD0: U3.41 (RD0), U8.2, U10.2
/VDP/VD1: U3.42 (RD1), U8.3, U10.3
/VDP/VD2: U3.43 (RD2), U8.15, U10.15
/VDP/VD3: U3.44 (RD3), U8.17, U10.17
/VDP/VD4: U3.45 (RD4), U9.2, U11.2
/VDP/VD5: U3.46 (RD5), U9.3, U11.3
/VDP/VD6: U3.47 (RD6), U9.15, U11.15
/VDP/VD7: U3.48 (RD7), U9.17, U11.17
/VDP/VIDEO: JP3.2, U3.21 (VIDEO)
/VDP/YS: J5.5, R35.2, R36.1
/VDP/~CAS0: R38.1, U8.16, U9.16
/VDP/~CAS1: R39.1, U10.16, U11.16
/VDP/~DHCLK: J14.2, RR3.2, U3.2 (~DHCLK)
/VDP/~DLCLK: J14.3, RR3.3, U3.3 (~DLCKL)
/VDP/~RAS: R40.1, U8.5, U9.5, U10.5, U11.5
/VDP/~VDP_RD: U3.31 (~CSR), U39.3
/VDP/~VDP_WR: U3.30 (~CSW), U39.11
/VDP/~VWR: R37.1, U8.4, U9.4, U10.4, U11.4
/~RD: U39.1; also elsewhere on the board
/~RESET: U3.9 (~RESET); also elsewhere on the board
/~VDP_CS: U39.2, U39.13; also elsewhere on the board
/~VDP_INT: RR2.7, U3.25 (~INT); also elsewhere on the board
/~VDP_WAIT: RR2.8, U3.26 (~LPS); also elsewhere on the board
/~WR: U39.12; also elsewhere on the board
GND: C54.2, C55.2, C56.1, C77.2, C82.2, C83.2, C84.2, C85.2, C89.1, C90.1, C92.1, C93.1, C94.2, J2.2 (Ext), J4.1, J4.2, J4.~, J5.1, J5.~, J14.13, JP5.3, L1.2, R7.2, R9.2, R14.1, R28.1, R35.1, RR9.1 (COM), U3.1 (GND), U3.20 (GND), U8.1, U8.18, U9.1, U9.18, U10.1, U10.18, U11.1, U11.18, U39.7 (GND), U43.7 (GND), U43.9, U43.11, U43.13, U47.1 (GND), U47.24 (GND); also elsewhere on the board
unnamed: C51.2, U47.2 (RIN)
unnamed: C52.2, U47.3 (GIN)
unnamed: C53.2, U47.4 (BIN)
unnamed: C54.1, U47.9 (YCLPC)
unnamed: C55.1, R7.1, U47.13 (IREF)
unnamed: C56.2, U3.33 (VBB)
unnamed: C59.1, R43.1
unnamed: C60.1, R44.1
unnamed: C61.1, R45.1
unnamed: C62.1, R46.1
unnamed: C63.1, R47.1
unnamed: C64.1, R48.1
unnamed: C77.1, U47.14 (VREF)
unnamed: C89.2, R2.2, U3.63 (XTAL1), Y1.2
unnamed: C90.2, R30.1, Y3.2
unnamed: C91.1, U47.17 (YTRAP)
unnamed: C91.2, L1.1
unnamed: C92.2, R2.1, U3.64 (XTAL2), Y1.1
unnamed: C93.2, R1.2, U43.1, Y3.1
unnamed: C94.1, R25.1, U47.6 (SCIN)
unnamed: JP3.1, RR9.3
unnamed: JP4.1, U43.6
unnamed: JP4.3, Q2.2 (B), R27.1
unnamed: JP5.2, U47.7 (NTSC/~PAL)
unnamed: JP6.1, U39.6
unnamed: JP6.2, R25.2
unnamed: Q2.3 (C), R28.2, U43.5
unnamed: R1.1, R30.2, U43.2, U43.3
unnamed: R9.1, U47.18 (FO)
unnamed: R37.2, U3.57 (R/~W)
unnamed: R38.2, U3.61 (~CAS0)
unnamed: R39.2, U3.60 (~CAS1)
unnamed: R40.2, U3.62 (~RAS)
unnamed: R43.2, U47.20 (CVOUT)
unnamed: R44.2, U47.15 (COUT)
unnamed: R45.2, U47.16 (YOUT)
unnamed: R46.2, U47.23 (ROUT)
unnamed: R47.2, U47.22 (GOUT)
unnamed: R48.2, U47.21 (BOUT)
unnamed: RR2.9, U3.27 (~LPD)
unnamed: RR3.4, U3.4 (~VDS)
unnamed: RR3.5, U3.59 (~CASX)
unnamed: RR3.6, U3.7 (BLEO)
unnamed: RR3.7, U3.10 (~YS)
VCC: J14.1, Q2.1 (E), R33.2, R36.2, RR2.1 (COM), RR3.1 (COM), U8.9, U9.9, U10.9, U11.9, U39.14 (VCC), U43.14 (VCC); also elsewhere on the board
VCCRGB: JP5.1, U47.12 (VCC), U47.19 (VCC); also elsewhere on the board
VCCVDP: JP3.3, U3.58 (VCC); also elsewhere on the board

Notes on the sheet:
JP3, JP4: 1-2: V9938; 2-3: V9958 (Use a wire link) JP4, JP5: 1-2: NTSC; 2-3: PAL (Use a wire link)
PAL: R9 - 16k, C91 - 18pF R9 - Tolerance 1%
PCB Layout Notes: Keep trace length between CXA1645 and 75 ohm resistors to minimum CXA1645 bypass capacitors: VCC1(12), VREF(14) -> GND1(1), VCC2(19) -> GND2(24)
Optional: PAL Clock Generator
Optional: RGB Output
Install Q2 only for V9938

Parts:
F1: 750mA; Cap_Cer_508
J7: JOYSTICK_A; Conn_Dsub_DE9M
J8: JOYSTICK_B; Conn_Dsub_DE9M
JP2: KBD_TYPE; Conn_Pin_Header_2x1_2.54mm
R34: 470; Res_762
RR6: 4.7k; Conn_SIL10
RR8: 4.7k; Conn_SIL6
U4: YM2149; IC_DIP40_600
U28, U29: 74HCT157; IC_DIP16_300
U35, U36: 74HCT74; IC_DIP14_300
U39: 74AHCT32; IC_DIP14_300
U42: 74LS07; IC_DIP14_300
U44: 74AHCT02; IC_DIP14_300

Connections:
/A0: U44.9; also elsewhere on the board
/A1: U44.11; also elsewhere on the board
/CAS_IN: U4.14 (IOA7); also elsewhere on the board
/CLK: U35.11 (CLK), U42.5; also elsewhere on the board
/D0: U4.37 (DA0); also elsewhere on the board
/D1: U4.36 (DA1); also elsewhere on the board
/D2: U4.35 (DA2); also elsewhere on the board
/D3: U4.34 (DA3); also elsewhere on the board
/D4: U4.33 (DA4); also elsewhere on the board
/D5: U4.32 (DA5); also elsewhere on the board
/D6: U4.31 (DA6); also elsewhere on the board
/D7: U4.30 (DA7); also elsewhere on the board
/KANA_LED: U4.6 (IOB7); also elsewhere on the board
/PSG/JB0: U4.13 (IOB0), U42.1
/PSG/JB1: U4.12 (IOB1), U42.11
/PSG/JB2: U4.11 (IOB2), U42.13
/PSG/JB3: U4.10 (IOB3), U42.3
/PSG/JOY_BCK: U4.20 (IOA1), U28.7 (2Y)
/PSG/JOY_FWD: U4.21 (IOA0), U28.4 (1Y)
/PSG/JOY_LFT: U4.19 (IOA2), U28.9 (3Y)
/PSG/JOY_OUT_A: J7.8, U4.9 (IOB4)
/PSG/JOY_OUT_B: J8.8, U4.8 (IOB5)
/PSG/JOY_RGT: U4.18 (IOA3), U28.12 (4Y)
/PSG/JOY_SEL: U4.7 (IOB6), U28.1 (~A~/B), U29.1 (~A~/B)
/PSG/JOY_TRG1: U4.17 (IOA4), U29.4 (1Y)
/PSG/JOY_TRG2: U4.16 (IOA5), U29.7 (2Y)
/PSG/KBD_TYPE: JP2.1, RR8.6, U4.15 (IOA6)
/PSG/PSG_BC1: U4.29 (BC1), U44.10
/PSG/PSG_BDIR: U4.27 (BDIR), U44.13
/PSG/~BCK_A: J7.2, RR6.3, U28.5 (2A)
/PSG/~BCK_B: J8.2, RR6.7, U28.6 (2B)
/PSG/~FWD_A: J7.1, RR6.2, U28.2 (1A)
/PSG/~FWD_B: J8.1, RR6.6, U28.3 (1B)
/PSG/~LFT_A: J7.3, RR6.4, U28.11 (3A)
/PSG/~LFT_B: J8.3, RR6.8, U28.10 (3B)
/PSG/~RGT_A: J7.4, RR6.5, U28.14 (4A)
/PSG/~RGT_B: J8.4, RR6.9, U28.13 (4B)
/PSG/~TRG1_A: J7.6, RR8.3, U29.2 (1A), U42.2
/PSG/~TRG1_B: J8.6, RR8.4, U29.3 (1B), U42.12
/PSG/~TRG2_A: J7.7, RR8.2, U29.5 (2A), U42.10
/PSG/~TRG2_B: J8.7, RR8.5, U29.6 (2B), U42.4
/PSG_SND: R34.1, U4.3 (CH_B), U4.4 (CH_A), U4.38 (CH_C); also elsewhere on the board
/~PSG_CS: U39.9, U44.5, U44.6; also elsewhere on the board
/~RESET: U4.23 (~RESET); also elsewhere on the board
GND: J7.9, J7.GND, J8.9, J8.GND, JP2.2, R34.2, U4.1 (GND), U4.24 (~A9), U28.8 (GND), U28.15 (~G), U29.8 (GND), U29.10 (3B), U29.11 (3A), U29.13 (4B), U29.14 (4A), U29.15 (~G), U35.7 (GND), U36.7 (GND), U39.7 (GND), U42.7 (GND), U44.7 (GND); also elsewhere on the board
unnamed: F1.1, J7.5, J8.5
unnamed: RR6.10, U36.3 (CLK), U36.11 (CLK), U42.6, U44.3
unnamed: U4.22 (CLOCK), U35.9 (Q)
unnamed: U35.8 (~Q), U35.12 (D)
unnamed: U36.1 (~CLR), U36.2 (D), U36.13 (~CLR), U44.4
unnamed: U36.8 (~Q), U44.2
unnamed: U36.5 (Q), U36.12 (D)
unnamed: U39.8, U44.8, U44.12
unnamed: U39.10, U44.1
VCC: F1.2, RR6.1 (COM), RR8.1 (COM), U4.25 (A8), U4.28 (BC2), U4.40 (VCC), U28.16 (VCC), U29.16 (VCC), U35.10 (~PR), U35.13 (~CLR), U35.14 (VCC), U36.4 (~PR), U36.10 (~PR), U36.14 (VCC), U39.14 (VCC), U42.14 (VCC), U44.14 (VCC); also elsewhere on the board

Notes on the sheet:
JP2: Japanese keyboard layout: Open (1) = JIS Closed (0) = ANSI/AIUEO/50on

Parts:
J11: KEYBOARD; Conn_Pin_Header_8x2_2.54mm
RR7: 4.7k; Conn_SIL10
U2: 82C55; IC_DIP40_600
U13: ATF16V8B; IC_DIP20_300
U22: 74HCT540; IC_DIP20_300
U23: 74HCT273; IC_DIP20_300
U30, U31: 74HCT153; IC_DIP16_300
U38: 74AHCT32; IC_DIP14_300
U40, U41: 74HCT30; IC_DIP14_300
U45: 74HCT00; IC_DIP14_300

Connections:
/A0: U2.9, U40.12; also elsewhere on the board
/A1: U2.8, U40.11; also elsewhere on the board
/A2: U40.6; also elsewhere on the board
/A3: U40.5; also elsewhere on the board
/A4: U40.4; also elsewhere on the board
/A5: U40.3; also elsewhere on the board
/A6: U40.2; also elsewhere on the board
/A7: U40.1; also elsewhere on the board
/A8: U41.11; also elsewhere on the board
/A9: U41.5; also elsewhere on the board
/A10: U41.4; also elsewhere on the board
/A11: U41.6; also elsewhere on the board
/A12: U41.3; also elsewhere on the board
/A13: U41.12; also elsewhere on the board
/A14: U13.2 (I1), U30.14 (A), U31.14 (A), U41.2; also elsewhere on the board
/A15: U13.1 (I/CLK), U30.2 (B), U31.2 (B), U41.1; also elsewhere on the board
/CAS_MOT: U2.13; also elsewhere on the board
/CAS_OUT: U2.12; also elsewhere on the board
/D0: U2.34, U22.18 (~Y1), U23.3 (D0); also elsewhere on the board
/D1: U2.33, U22.17 (~Y2), U23.18 (D7); also elsewhere on the board
/D2: U2.32, U22.16 (~Y3), U23.17 (D6); also elsewhere on the board
/D3: U2.31, U22.15 (~Y4), U23.4 (D1); also elsewhere on the board
/D4: U2.30, U22.14 (~Y5), U23.7 (D2); also elsewhere on the board
/D5: U2.29, U22.13 (~Y6), U23.14 (D5); also elsewhere on the board
/D6: U2.28, U22.12 (~Y7), U23.13 (D4); also elsewhere on the board
/D7: U2.27, U22.11 (~Y8), U23.8 (D3); also elsewhere on the board
/KANA_LED: J11.14; also elsewhere on the board
/KEY_CLICK: U2.10; also elsewhere on the board
/PPI/CAPS_LED: J11.12, U2.11
/PPI/COLUMN0: J11.1, RR7.2, U2.18
/PPI/COLUMN1: J11.3, RR7.3, U2.19
/PPI/COLUMN2: J11.5, RR7.4, U2.20
/PPI/COLUMN3: J11.7, RR7.5, U2.21
/PPI/COLUMN4: J11.9, RR7.6, U2.22
/PPI/COLUMN5: J11.11, RR7.7, U2.23
/PPI/COLUMN6: J11.13, RR7.8, U2.24
/PPI/COLUMN7: J11.15, RR7.9, U2.25
/PPI/ROW_A: J11.4, U2.14
/PPI/ROW_B: J11.6, U2.15
/PPI/ROW_C: J11.8, U2.16
/PPI/ROW_D: J11.10, U2.17
/PPI/SB_SLT_A: U13.6 (I5), U31.7 (1Y)
/PPI/SB_SLT_B: U13.7 (I6), U31.9 (2Y)
/PPI/SLT_A: U13.8 (I7), U30.7 (1Y)
/PPI/SLT_B: U13.9 (I8), U30.9 (2Y)
/PPI/~FFFF: U13.5 (I4), U38.2, U38.6
/PPI/~SLTSL3: U13.17 (I/O3), U38.1
/PPI/~SUB_RD: U22.1 (~G1), U22.19 (~G2), U38.11
/PPI/~SUB_REG_CS: U38.3, U38.10, U38.12
/PPI/~SUB_WR: U23.11 (CP), U38.8
/PRT_BUSY: RR7.10; also elsewhere on the board
/RESET: U2.35; also elsewhere on the board
/ROM_A16: U13.13 (I/O7); also elsewhere on the board
/ROM_A17: U13.12 (I/O8); also elsewhere on the board
/~MEM_RD: U13.16 (I/O4); also elsewhere on the board
/~MREQ: U13.3 (I2); also elsewhere on the board
/~PPI_CS: U2.6, U45.4; also elsewhere on the board
/~RAM_SL: U13.15 (I/O5); also elsewhere on the board
/~RD: U2.5, U13.11 (I9/~OE), U38.13; also elsewhere on the board
/~RESET: U23.1 (~MR), U45.2; also elsewhere on the board
/~RFSH: U13.4 (I3); also elsewhere on the board
/~ROM_CS: U13.14 (I/O6); also elsewhere on the board
/~SLTSL1: U13.19 (I/O1); also elsewhere on the board
/~SLTSL2: U13.18 (I/O2); also elsewhere on the board
/~WR: U2.36, U38.9; also elsewhere on the board
GND: J11.16, U2.7, U13.10 (GND), U22.10 (GND), U23.10 (GND), U30.8 (GND), U31.1 (~1G), U31.8 (GND), U31.15 (~2G), U38.7 (GND), U40.7 (GND), U41.7 (GND), U45.7 (GND); also elsewhere on the board
unnamed: U2.1, U30.11 (2C1)
unnamed: U2.2, U30.5 (1C1)
unnamed: U2.3, U30.10 (2C0)
unnamed: U2.4, U30.6 (1C0)
unnamed: U2.37, U30.13 (2C3)
unnamed: U2.38, U30.3 (1C3)
unnamed: U2.39, U30.12 (2C2)
unnamed: U2.40, U30.4 (1C2)
unnamed: U22.2 (A1), U23.2 (Q0), U31.6 (1C0)
unnamed: U22.3 (A2), U23.19 (Q7), U31.10 (2C0)
unnamed: U22.4 (A3), U23.16 (Q6), U31.5 (1C1)
unnamed: U22.5 (A4), U23.5 (Q1), U31.11 (2C1)
unnamed: U22.6 (A5), U23.6 (Q2), U31.4 (1C2)
unnamed: U22.7 (A6), U23.15 (Q5), U31.12 (2C2)
unnamed: U22.8 (A7), U23.12 (Q4), U31.3 (1C3)
unnamed: U22.9 (A8), U23.9 (Q3), U31.13 (2C3)
unnamed: U30.1 (~1G), U30.15 (~2G), U45.3, U45.5
unnamed: U38.4, U41.8
unnamed: U38.5, U40.8
unnamed: U45.1, U45.6
VCC: J11.2, RR7.1 (COM), U2.26, U13.20 (VCC), U22.20 (VCC), U23.20 (VCC), U30.16 (VCC), U31.16 (VCC), U38.14 (VCC), U40.14 (VCC), U41.14 (VCC), U45.14 (VCC); also elsewhere on the board

Notes on the sheet:
Keyboard Pull-ups

Parts:
RR4: 10k; Conn_SIL10
SLOT1, SLOT2: MSX_SLOT_HOST; Conn_Edge_50P
U14: ATF16V8B; IC_DIP20_300
U19, U20, U21: 74F541; IC_DIP20_300
U25: 74F245; IC_DIP20_300

Connections:
/A0: U19.7 (A5); also elsewhere on the board
/A1: U19.6 (A4); also elsewhere on the board
/A2: U19.5 (A3); also elsewhere on the board
/A3: U19.4 (A2); also elsewhere on the board
/A4: U19.3 (A1); also elsewhere on the board
/A5: U19.2 (A0); also elsewhere on the board
/A6: U20.5 (A3); also elsewhere on the board
/A7: U20.4 (A2); also elsewhere on the board
/A8: U20.3 (A1); also elsewhere on the board
/A9: U20.8 (A6); also elsewhere on the board
/A10: U20.7 (A5); also elsewhere on the board
/A11: U20.6 (A4); also elsewhere on the board
/A12: U20.2 (A0); also elsewhere on the board
/A13: U19.9 (A7); also elsewhere on the board
/A14: U14.2 (I1), U19.8 (A6); also elsewhere on the board
/A15: U14.1 (I/CLK), U20.9 (A7); also elsewhere on the board
/CLK: U21.9 (A7); also elsewhere on the board
/D0: U25.9 (A7); also elsewhere on the board
/D1: U25.8 (A6); also elsewhere on the board
/D2: U25.7 (A5); also elsewhere on the board
/D3: U25.6 (A4); also elsewhere on the board
/D4: U25.5 (A3); also elsewhere on the board
/D5: U25.4 (A2); also elsewhere on the board
/D6: U25.3 (A1); also elsewhere on the board
/D7: U25.2 (A0); also elsewhere on the board
/SLT1_SND: SLOT1.49 (SOUNDIN); also elsewhere on the board
/SLT2_SND: SLOT2.49 (SOUNDIN); also elsewhere on the board
/Slots/BA0: SLOT1.28 (A0), SLOT2.28 (A0), U19.13 (Y5)
/Slots/BA1: SLOT1.27 (A1), SLOT2.27 (A1), U19.14 (Y4)
/Slots/BA2: SLOT1.30 (A2), SLOT2.30 (A2), U19.15 (Y3)
/Slots/BA3: SLOT1.29 (A3), SLOT2.29 (A3), U19.16 (Y2)
/Slots/BA4: SLOT1.32 (A4), SLOT2.32 (A4), U19.17 (Y1)
/Slots/BA5: SLOT1.31 (A5), SLOT2.31 (A5), U19.18 (Y0)
/Slots/BA6: SLOT1.22 (A6), SLOT2.22 (A6), U20.15 (Y3)
/Slots/BA7: SLOT1.21 (A7), SLOT2.21 (A7), U20.16 (Y2)
/Slots/BA8: SLOT1.24 (A8), SLOT2.24 (A8), U20.17 (Y1)
/Slots/BA9: SLOT1.17 (A9), SLOT2.17 (A9), U20.12 (Y6)
/Slots/BA10: SLOT1.20 (A10), SLOT2.20 (A10), U20.13 (Y5)
/Slots/BA11: SLOT1.19 (A11), SLOT2.19 (A11), U20.14 (Y4)
/Slots/BA12: SLOT1.23 (A12), SLOT2.23 (A12), U20.18 (Y0)
/Slots/BA13: SLOT1.26 (A13), SLOT2.26 (A13), U19.11 (Y7)
/Slots/BA14: SLOT1.25 (A14), SLOT2.25 (A14), U19.12 (Y6)
/Slots/BA15: SLOT1.18 (A15), SLOT2.18 (A15), U20.11 (Y7)
/Slots/BD0: RR4.10, SLOT1.34 (D0), SLOT2.34 (D0), U25.11 (B7)
/Slots/BD1: RR4.9, SLOT1.33 (D1), SLOT2.33 (D1), U25.12 (B6)
/Slots/BD2: RR4.8, SLOT1.36 (D2~), SLOT2.36 (D2~), U25.13 (B5)
/Slots/BD3: RR4.7, SLOT1.35 (D3), SLOT2.35 (D3), U25.14 (B4)
/Slots/BD4: RR4.6, SLOT1.38 (D4), SLOT2.38 (D4), U25.15 (B3)
/Slots/BD5: RR4.5, SLOT1.37 (D5), SLOT2.37 (D5), U25.16 (B2)
/Slots/BD6: RR4.4, SLOT1.40 (D6), SLOT2.40 (D6), U25.17 (B1)
/Slots/BD7: RR4.3, SLOT1.39 (D7), SLOT2.39 (D7), U25.18 (B0)
/Slots/B_CLK: SLOT1.42 (CLOCK), SLOT2.42 (CLOCK), U21.11 (Y7)
/Slots/SLT_DIR: U14.12 (I/O8), U25.1 (A->B)
/Slots/~B_IORQ: SLOT1.11 (~IORQ), SLOT2.11 (~IORQ), U14.8 (I7), U21.15 (Y3)
/Slots/~B_M1: SLOT1.9 (~M1), SLOT2.9 (~M1), U14.7 (I6), U21.16 (Y2)
/Slots/~B_MREQ: SLOT1.12 (~MERQ), SLOT2.12 (~MERQ), U21.14 (Y4)
/Slots/~B_RD: SLOT1.14 (~RD), SLOT2.14 (~RD), U14.9 (I8), U21.18 (Y0)
/Slots/~B_RESET: SLOT1.15 (~RESET), SLOT2.15 (~RESET), U21.12 (Y6)
/Slots/~B_RFSH: SLOT1.6 (~RFSH), SLOT2.6 (~RFSH), U21.13 (Y5)
/Slots/~B_WR: SLOT1.13 (~WR), SLOT2.13 (~WR), U21.17 (Y1)
/Slots/~CS1: SLOT1.1 (~CS1), SLOT2.1 (~CS1), U14.14 (I/O6)
/Slots/~CS2: SLOT1.2 (~CS2), SLOT2.2 (~CS2), U14.15 (I/O5)
/Slots/~CS12: SLOT1.3 (~CS12), SLOT2.3 (~CS12), U14.13 (I/O7)
/~BUSDIR1: SLOT1.10 (~BUSDIR), U14.5 (I4); also elsewhere on the board
/~BUSDIR2: SLOT2.10 (~BUSDIR), U14.6 (I5); also elsewhere on the board
/~IORQ: U21.5 (A3); also elsewhere on the board
/~KBD_WAIT: U14.16 (I/O4); also elsewhere on the board
/~M1: U21.4 (A2); also elsewhere on the board
/~M1_WAIT: U14.18 (I/O2); also elsewhere on the board
/~MREQ: U21.6 (A4); also elsewhere on the board
/~RD: U21.2 (A0); also elsewhere on the board
/~RESET: U21.8 (A6); also elsewhere on the board
/~RFSH: U21.7 (A5); also elsewhere on the board
/~SLTSL1: SLOT1.4 (~SLTSL), U14.3 (I2); also elsewhere on the board
/~SLTSL2: SLOT2.4 (~SLTSL), U14.4 (I3); also elsewhere on the board
/~SLT_INT: SLOT1.8 (~INT), SLOT2.8 (~INT); also elsewhere on the board
/~SLT_WAIT: SLOT1.7 (~WAIT), SLOT2.7 (~WAIT), U14.11 (I9/~OE); also elsewhere on the board
/~VDP_WAIT: U14.17 (I/O3); also elsewhere on the board
/~WAIT: U14.19 (I/O1); also elsewhere on the board
/~WR: U21.3 (A1); also elsewhere on the board
GND: SLOT1.41 (GND), SLOT1.43 (GND), SLOT1.44 (SW1), SLOT1.46 (SW2), SLOT2.41 (GND), SLOT2.43 (GND), SLOT2.44 (SW1), SLOT2.46 (SW2), U14.10 (GND), U19.1 (G1), U19.10 (GND), U19.19 (G2), U20.1 (G1), U20.10 (GND), U20.19 (G2), U21.1 (G1), U21.10 (GND), U21.19 (G2), U25.10 (GND), U25.19 (CE); also elsewhere on the board
VCC: RR4.1 (COM), SLOT1.45 (+5V), SLOT1.47 (+5V), SLOT2.45 (+5V), SLOT2.47 (+5V), U14.20 (VCC), U19.20 (VCC), U20.20 (VCC), U21.20 (VCC), U25.20 (VCC); also elsewhere on the board
VDD: SLOT1.48 (+12V), SLOT2.48 (+12V); also elsewhere on the board
VSS: SLOT1.50 (-12V), SLOT2.50 (-12V); also elsewhere on the board

Notices in the files:
Keyboard/KiCad/Omega-Keyboard.kicad_pcb:
Copyright (C) 2018, 2020 Sergey Kiselev
Mainboard/KiCad/Omega-Mainboard.kicad_pcb:
Copyright (C) 2018-2025 Sergey Kiselev
