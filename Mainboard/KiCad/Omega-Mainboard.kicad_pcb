# Repository skiselev/omega (continued)

## KiCad design Mainboard/KiCad/Omega-Mainboard.kicad_pcb (continued)

Schematic: Omega-Memory.sch

Parts:
J12: RAM_EXT; Conn_Pin_Header_20x2_2.54mm
JP1: ROM_A18; Conn_Pin_Header_2x1_2.54mm
JP7, JP8: RAM_SIZE; Conn_Pin_Header_2x3_2.54mm
R13: 10k; Res_762
RR10: 4.7k; Conn_SIL6
U6: SST39SF040; IC_DIP32_600
U7: AS6C4008; IC_DIP32_600
U15, U16, U17, U18: 74HCT670; IC_DIP16_300
U26: 74F245; IC_DIP20_300
U32: 74AHCT138; IC_DIP16_300
U37: 74AHCT32; IC_DIP14_300

Connections:
/A0: J12.31, U6.12 (A0), U7.12 (A0), U15.5 (Ra), U15.14 (Wa), U16.5 (Ra), U16.14 (Wa), U17.14 (Wa), U18.14 (Wa); also elsewhere on the board
/A1: J12.29, U6.11 (A1), U7.11 (A1), U15.4 (Rb), U15.13 (Wb), U16.4 (Rb), U16.13 (Wb), U17.13 (Wb), U18.13 (Wb); also elsewhere on the board
/A2: J12.27, U6.10 (A2), U7.10 (A2); also elsewhere on the board
/A3: J12.25, U6.9 (A3), U7.9 (A3); also elsewhere on the board
/A4: J12.23, U6.8 (A4), U7.8 (A4); also elsewhere on the board
/A5: J12.21, U6.7 (A5), U7.7 (A5); also elsewhere on the board
/A6: J12.19, U6.6 (A6), U7.6 (A6); also elsewhere on the board
/A7: J12.17, U6.5 (A7), U7.5 (A7); also elsewhere on the board
/A8: J12.20, U6.27 (A8), U7.27 (A8); also elsewhere on the board
/A9: J12.22, U6.26 (A9), U7.26 (A9); also elsewhere on the board
/A10: J12.28, U6.23 (A10), U7.23 (A10); also elsewhere on the board
/A11: J12.24, U6.25 (A11), U7.25 (A11); also elsewhere on the board
/A12: J12.15, U6.4 (A12), U7.4 (A12); also elsewhere on the board
/A13: J12.18, U6.28 (A13), U7.28 (A13); also elsewhere on the board
/A14: U6.29 (A14), U17.5 (Ra), U18.5 (Ra); also elsewhere on the board
/A15: U6.3 (A15), U17.4 (Rb), U18.4 (Rb); also elsewhere on the board
/D0: U16.3 (D4), U16.6 (Q4), U18.3 (D4), U26.9 (A7); also elsewhere on the board
/D1: U16.2 (D3), U16.7 (Q3), U18.2 (D3), U26.8 (A6); also elsewhere on the board
/D2: U16.1 (D2), U16.9 (Q2), U18.1 (D2), U26.7 (A5); also elsewhere on the board
/D3: U16.10 (Q1), U16.15 (D1), U18.15 (D1), U26.6 (A4); also elsewhere on the board
/D4: U15.3 (D4), U15.6 (Q4), U17.3 (D4), U26.5 (A3); also elsewhere on the board
/D5: JP8.5, JP8.6, U15.2 (D3), U15.7 (Q3), U17.2 (D3), U26.4 (A2); also elsewhere on the board
/D6: JP8.1, JP8.2, U15.10 (Q1), U15.15 (D1), U17.15 (D1), U26.3 (A1); also elsewhere on the board
/D7: JP8.3, JP8.4, U15.1 (D2), U15.9 (Q2), U17.1 (D2), U26.2 (A0); also elsewhere on the board
/Memory/MD0: J12.33, U6.13 (DQ0), U7.13 (DQ0), U26.11 (B7)
/Memory/MD1: J12.35, U6.14 (DQ1), U7.14 (DQ1), U26.12 (B6)
/Memory/MD2: J12.37, U6.15 (DQ2), U7.15 (DQ2), U26.13 (B5)
/Memory/MD3: J12.38, U6.17 (DQ3), U7.17 (DQ3), U26.14 (B4)
/Memory/MD4: J12.36, U6.18 (DQ4), U7.18 (DQ4), U26.15 (B3)
/Memory/MD5: J12.34, U6.19 (DQ5), U7.19 (DQ5), U26.16 (B2)
/Memory/MD6: J12.32, U6.20 (DQ6), U7.20 (DQ6), U26.17 (B1)
/Memory/MD7: J12.30, U6.21 (DQ7), U7.21 (DQ7), U26.18 (B0)
/Memory/RAM_A14: J12.13, U7.3 (A14), U18.6 (Q4)
/Memory/RAM_A15: J12.12, U7.31 (A15), U18.7 (Q3)
/Memory/RAM_A16: J12.11, U7.2 (A16), U18.9 (Q2)
/Memory/RAM_A17: J12.14, U7.30 (A17), U18.10 (Q1)
/Memory/RAM_A18: J12.9, U7.1 (A18), U17.6 (Q4)
/Memory/RAM_A19: JP7.1, JP7.2, RR10.2, U17.7 (Q3), U32.1 (A0)
/Memory/RAM_A20: JP7.3, JP7.4, RR10.3, U17.10 (Q1), U32.2 (A1)
/Memory/RAM_A21: JP7.5, JP7.6, RR10.4, U17.9 (Q2), U32.3 (A2)
/Memory/ROM_A18: JP1.2, R13.1, U6.1 (A18)
/Memory/~PAGE_RD: U15.11 (~Er), U16.11 (~Er), U37.3
/Memory/~PAGE_WR: U15.12 (~Ew), U16.12 (~Ew), U17.12 (~Ew), U18.12 (~Ew), U37.11
/Memory/~RAM0_CS: U7.22 (~CE), U32.15 (O0)
/Memory/~RAM1_CS: J12.4, U32.14 (O1)
/Memory/~RAM2_CS: J12.3, U32.13 (O2)
/Memory/~RAM3_CS: J12.6, U32.12 (O3)
/Memory/~RAM4_CS: J12.5, U32.11 (O4)
/Memory/~RAM5_CS: J12.8, U32.10 (O5)
/Memory/~RAM6_CS: J12.7, U32.9 (O6)
/Memory/~RAM7_CS: J12.10, U32.7 (O7)
/ROM_A16: U6.2 (A16); also elsewhere on the board
/ROM_A17: U6.30 (A17); also elsewhere on the board
/~MEM_RD: U26.1 (A->B); also elsewhere on the board
/~PAGE_CS: U37.2, U37.12; also elsewhere on the board
/~RAM_SL: U32.4 (E1), U32.5 (E2); also elsewhere on the board
/~RD: J12.26, U6.24 (~OE), U7.24 (~OE), U37.1; also elsewhere on the board
/~ROM_CS: U6.22 (~CE); also elsewhere on the board
/~WR: J12.16, U6.31 (~WE), U7.29 (~WE), U37.13; also elsewhere on the board
GND: J12.39, J12.40, R13.2, RR10.1 (COM), U6.16 (GND), U7.16 (GND), U15.8 (GND), U16.8 (GND), U17.8 (GND), U17.11 (~Er), U18.8 (GND), U18.11 (~Er), U26.10 (GND), U26.19 (CE), U32.8 (GND), U37.7 (GND); also elsewhere on the board
VCC: J12.1, J12.2, JP1.1, U6.32 (VCC), U7.32 (VCC), U15.16 (VCC), U16.16 (VCC), U17.16 (VCC), U18.16 (VCC), U26.20 (VCC), U32.6 (E3), U32.16 (VCC), U37.14 (VCC); also elsewhere on the board

Parts:
C1, C2, C3, C4, C6, C7, C8, C9, C10, C11, C12, C13, C14, C15, C16, C17, C18, C19, C20, C21, C22, C23, C24, C25, C26, C27, C28, C29, C30, C31, C32, C33, C34, C35, C36, C37, C38, C39, C40, C41, C42, C43, C44, C45, C46, C47, C48, C49, C50, C57, C58: 0.1uF; Cap_Cer_508
C65, C66, C67: 100uF; Cap_Elec_Radial_6.3mm
C68, C69, C70: 10uF; Cap_Pol_508_3
C71, C72, C73, C74, C75, C76: 10uF; Cap_Elec_Radial_5mm
C78: 1uF; Cap_Elec_Radial_5mm
C79, C80: 22nF; Cap_Cer_508
C81: 1.5nF; Cap_Cer_508
D1: 1N4148; Diode_762
J3: Audio; Conn_RCA_Right
J6: Cassette; Conn_DIN_8pin
L2, L3: 5.6uH; Res_762
Q1: PN2907A; Transistor_TO92_EBC_254
R3: 470k; Res_762
R4: 220k; Res_762
R8: 47k; Res_762
R10: 20k; Res_762
R11, R12: 10k; Res_762
R15: 5.6k; Res_762
R16, R17, R18, R19, R20, R21, R22: 4.7k; Res_762
R23, R24: 2.7k; Res_762
R26: 2.2k; Res_762
R31, R32: 1k; Res_762
R41, R42: 100; Res_762
RY1: Relay_5V; Relay_SPDT
U48: MCP6281; IC_DIP8_300
U49: LM311; IC_DIP8_300

Connections:
/AUDIO: C76.2, J3.1 (In), R8.1; also elsewhere on the board
/CAS_IN: R4.2, R32.1, U49.7; also elsewhere on the board
/CAS_MOT: R31.1; also elsewhere on the board
/CAS_OUT: C78.1; also elsewhere on the board
/KEY_CLICK: C73.1; also elsewhere on the board
/PSG_SND: C72.1; also elsewhere on the board
/SLT1_SND: C74.1; also elsewhere on the board
/SLT2_SND: C75.1; also elsewhere on the board
GND: C1.2, C2.2, C3.2, C4.2, C6.2, C7.2, C8.2, C9.2, C10.2, C11.2, C12.2, C13.2, C14.2, C15.2, C16.2, C17.2, C18.2, C19.2, C20.2, C21.2, C22.2, C23.2, C24.2, C25.2, C26.2, C27.2, C28.2, C29.2, C30.2, C31.2, C32.2, C33.2, C34.2, C35.2, C36.2, C37.2, C38.2, C39.2, C40.2, C41.2, C42.2, C43.2, C44.2, C45.2, C46.2, C47.2, C48.2, C49.2, C50.2, C57.2, C58.2, C65.2, C66.2, C67.1, C68.2, C69.2, C70.2, C71.2, C79.2, J3.2 (Ext), J6.1, J6.2, J6.3, J6.8, J6.~, Q1.3 (C), R8.2, R22.1, R23.2, R42.2, U48.4 (V-), U49.1 (GND), U49.4 (V-); also elsewhere on the board
unnamed: C57.1, R21.1, R22.2, U48.3 (+)
unnamed: C71.1, R12.2, R20.1, R23.1, R24.1
unnamed: C72.2, R26.2
unnamed: C73.2, R10.2
unnamed: C74.2, R16.2
unnamed: C75.2, R17.2
unnamed: C76.1, R41.2
unnamed: C78.2, R18.1
unnamed: C79.1, R18.2, R19.1
unnamed: C80.1, J6.5
unnamed: C80.2, R11.2
unnamed: C81.1, R10.1, R15.1, R16.1, R17.1, R26.1, U48.2 (-)
unnamed: C81.2, R15.2, R41.1, U48.6
unnamed: D1.2 (A), Q1.1 (E), RY1.9
unnamed: J6.4, R19.2, R42.1
unnamed: J6.6, RY1.5, RY1.6
unnamed: J6.7, RY1.10
unnamed: Q1.2 (B), R31.2
unnamed: R3.2, R11.1, R12.1, U49.3 (-)
unnamed: R4.1, R20.2, U49.2 (+)
VCC: C1.1, C2.1, C4.1, C6.1, C7.1, C8.1, C9.1, C10.1, C11.1, C12.1, C13.1, C14.1, C15.1, C16.1, C17.1, C18.1, C19.1, C20.1, C21.1, C22.1, C23.1, C24.1, C25.1, C26.1, C27.1, C28.1, C29.1, C30.1, C31.1, C32.1, C33.1, C34.1, C35.1, C36.1, C37.1, C38.1, C39.1, C40.1, C41.1, C42.1, C43.1, C44.1, C45.1, C46.1, C48.1, C49.1, C65.1, C68.1, D1.1 (K), L2.1, L3.1, R3.1, R21.2, R24.2, R32.2, RY1.2, U48.7 (V+), U49.8 (V+); also elsewhere on the board
VCCRGB: C47.1, C50.1, C69.1, L3.2; also elsewhere on the board
VCCVDP: C3.1, C58.1, C70.1, L2.2; also elsewhere on the board
VDD: C66.1; also elsewhere on the board
VSS: C67.2; also elsewhere on the board

Notes on the sheet:
C5: RTC
Optional: Cassete I/O

Parts:
BT1: CR2032; Battery_Holder_CR2032_Universal
C5: 0.1uF; Cap_Cer_508
C86, C87: 33pF; Cap_Cer_508
C88: 30pF; C_Trim_Murata
J9: PRINTER; Conn_Micro_Ribbon_14F
J13: ~RST~/~NMI; Conn_Pin_Header_2x2_2.54mm
R5, R6: 100k; Res_762
R29: 1k; Res_762
RR1: 10k; Conn_SIL10
RR5: 4.7k; Conn_SIL10
U1: Z84C00; IC_DIP40_600
U5: RP5C01; IC_DIP18_300
U12: ATF16V8B; IC_DIP20_300
U24: 74HCT273; IC_DIP20_300
U27: 74HCT175; IC_DIP16_300
U33: 74AHCT125; IC_DIP14_300
U34, U35: 74HCT74; IC_DIP14_300
U37: 74AHCT32; IC_DIP14_300
U42: 74LS07; IC_DIP14_300
U45: 74HCT00; IC_DIP14_300
U46: ADM691A; IC_DIP16_300
Y2: 32768 Hz; Crystal_32K_Horiz

Connections:
/A0: U1.30, U12.9 (I8); also elsewhere on the board
/A1: U1.31; also elsewhere on the board
/A2: U1.32, U12.8 (I7); also elsewhere on the board
/A3: U1.33, U12.7 (I6); also elsewhere on the board
/A4: U1.34, U12.6 (I5); also elsewhere on the board
/A5: U1.35, U12.5 (I4); also elsewhere on the board
/A6: U1.36, U12.4 (I3); also elsewhere on the board
/A7: U1.37, U12.3 (I2); also elsewhere on the board
/A8: U1.38; also elsewhere on the board
/A9: U1.39; also elsewhere on the board
/A10: U1.40; also elsewhere on the board
/A11: U1.1; also elsewhere on the board
/A12: U1.2; also elsewhere on the board
/A13: U1.3; also elsewhere on the board
/A14: U1.4; also elsewhere on the board
/A15: U1.5; also elsewhere on the board
/CLK: U42.9; also elsewhere on the board
/D0: RR1.3, U1.14, U5.11 (D0), U24.17 (D6), U27.5 (D1), U35.2 (D); also elsewhere on the board
/D1: RR1.4, U1.15, U5.12 (D1), U24.14 (D5), U27.4 (D0), U33.3; also elsewhere on the board
/D2: RR1.5, U1.12, U5.13 (D2), U24.4 (D1), U27.12 (D2); also elsewhere on the board
/D3: RR1.6, U1.8, U5.14 (D3), U24.7 (D2), U27.13 (D3); also elsewhere on the board
/D4: RR1.7, U1.7, U24.13 (D4); also elsewhere on the board
/D5: RR1.8, U1.9, U24.8 (D3); also elsewhere on the board
/D6: RR1.9, U1.10, U24.18 (D7); also elsewhere on the board
/D7: RR1.10, U1.13, U24.3 (D0); also elsewhere on the board
/PRT_BUSY: J9.11, U33.2; also elsewhere on the board
/Processor/ALARM: RR1.2, U5.15 (~ALARM)
/Processor/PD0: J9.2, U24.16 (Q6)
/Processor/PD1: J9.3, U24.15 (Q5)
/Processor/PD2: J9.4, U24.5 (Q1)
/Processor/PD3: J9.5, U24.6 (Q2)
/Processor/PD4: J9.6, U24.12 (Q4)
/Processor/PD5: J9.7, U24.9 (Q3)
/Processor/PD6: J9.8, U24.19 (Q7)
/Processor/PD7: J9.9, U24.2 (Q0)
/Processor/RTC_VCC: C5.1, U5.2 (CS), U5.18 (VCC), U46.2
/Processor/~BUSREQ: RR5.3, U1.25
/Processor/~INT: U1.16, U45.8
/Processor/~NMI: J13.3, RR5.4, U1.17
/Processor/~PRT_BSY_RD: U33.1, U37.6
/Processor/~PRT_CMD_CS: U12.13 (I/O7), U37.5, U37.10
/Processor/~PRT_DAT_WR: U12.12 (I/O8), U24.11 (CP)
/Processor/~PRT_STB_WR: U35.3 (CLK), U37.8
/Processor/~RTC_AD_WR: U12.17 (I/O3), U27.9 (CP)
/Processor/~RTC_CS: U12.16 (I/O4), U46.13
/Processor/~RTC_CS_B: U5.1 (~CS), U46.12
/Processor/~STROBE: J9.1, U35.5 (Q)
/RESET: U46.16; also elsewhere on the board
/~BUSDIR1: RR5.7; also elsewhere on the board
/~BUSDIR2: RR5.6; also elsewhere on the board
/~IORQ: U1.20, U12.2 (I1); also elsewhere on the board
/~KBD_WAIT: RR5.2; also elsewhere on the board
/~M1: U1.27, U12.11 (I9/~OE), U34.2 (D); also elsewhere on the board
/~M1_WAIT: U34.5 (Q), U34.12 (D); also elsewhere on the board
/~MREQ: U1.19; also elsewhere on the board
/~PAGE_CS: U12.15 (I/O5); also elsewhere on the board
/~PPI_CS: U12.14 (I/O6); also elsewhere on the board
/~PSG_CS: U12.19 (I/O1); also elsewhere on the board
/~RD: U1.21, U5.8 (~RD), U37.4; also elsewhere on the board
/~RESET: J13.1, U1.26, U24.1 (~MR), U27.1 (~MR), U35.4 (~PR), U46.15; also elsewhere on the board
/~RFSH: U1.28; also elsewhere on the board
/~SLT_INT: RR5.9, U45.13; also elsewhere on the board
/~SLT_WAIT: RR5.10; also elsewhere on the board
/~VDP_CS: U12.18 (I/O2); also elsewhere on the board
/~VDP_INT: U45.12; also elsewhere on the board
/~WAIT: U1.24; also elsewhere on the board
/~WR: U1.22, U5.10 (~WR), U12.1 (I/CLK), U37.9; also elsewhere on the board
GND: BT1.2 (-), C5.2, C86.1, C87.1, C88.1, J9.14, J9.GND, J13.2, J13.4, R6.2, U1.29, U5.9 (GND), U12.10 (GND), U24.10 (GND), U27.8 (GND), U33.4, U33.5, U33.7 (GND), U33.9, U33.10, U33.12, U33.13, U34.7 (GND), U35.7 (GND), U37.7 (GND), U42.7 (GND), U45.7 (GND), U46.4, U46.9, Y2.~; also elsewhere on the board
unnamed: BT1.1 (+), U46.1
unnamed: C86.2, R5.1, U5.17 (OSCOUT)
unnamed: C87.2, R5.2, Y2.2
unnamed: C88.2, U5.16 (OSCIN), Y2.1
unnamed: R6.1, U5.3 (ADJ)
unnamed: R29.2, U1.6, U34.3 (CLK), U34.11 (CLK), U42.8
unnamed: U5.5 (A1), U27.2 (Q0)
unnamed: U5.4 (A0), U27.7 (Q1)
unnamed: U5.6 (A2), U27.10 (Q2)
unnamed: U5.7 (A3), U27.15 (Q3)
unnamed: U34.4 (~PR), U34.9 (Q)
unnamed: U45.9, U45.10, U45.11
VCC: R29.1, RR1.1 (COM), RR5.1 (COM), U1.11, U12.20 (VCC), U24.20 (VCC), U27.16 (VCC), U33.14 (VCC), U34.1 (~CLR), U34.10 (~PR), U34.13 (~CLR), U34.14 (VCC), U35.1 (~CLR), U35.14 (VCC), U37.14 (VCC), U42.14 (VCC), U45.14 (VCC), U46.3; also elsewhere on the board

Board: 2 copper layers, 333.4 x 149.9 mm, 248 parts (0 on the bottom side), 357 nets.

## KiCad design Keyboard/KiCad/Omega-Keyboard.kicad_pcb

Parts:
C1, C2: 0.1uF; Cap_Cer_508
C3: 10uF; Cap_Tant_508
D1: POWER; LED_3mm
D2: CAPS; CHERRY_MX_LED
D3: KANA; CHERRY_MX_LED
D4, D5, D6: 1N4148; Diode_762
HOLE1, HOLE2, HOLE3, HOLE4, HOLE5, HOLE6, HOLE7: HOLE; Hole_3mm
J1: KEYBOARD; Conn_Pin_Header_8x2_2.54mm
R1, R2, R3: 470; Res_762
RN1: 4.7k; Conn_SIL6
SW1: 0; CHERRY_PCB_100H
SW2: 1; CHERRY_PCB_100H
SW3: 2; CHERRY_PCB_100H
SW4: 3; CHERRY_PCB_100H
SW5: 4; CHERRY_PCB_100H
SW6: 5; CHERRY_PCB_100H
SW7: 6; CHERRY_PCB_100H
SW8: 7; CHERRY_PCB_100H
SW9: 8; CHERRY_PCB_100H
SW10: 9; CHERRY_PCB_100H
SW11: MINUS; CHERRY_PCB_100H
SW12: EQUALS; CHERRY_PCB_100H
SW13: BACK_SLASH; CHERRY_PCB_150H
SW14: LEFT_BRACKET; CHERRY_PCB_100H
SW15: RIGHT_BRACKET; CHERRY_PCB_100H
SW16: SEMICOLON; CHERRY_PCB_100H
SW17: QUOTE; CHERRY_PCB_100H
SW18: TILDE; CHERRY_PCB_100H
SW19: COMMA; CHERRY_PCB_100H
SW20: PERIOD; CHERRY_PCB_100H
SW21: SLASH; CHERRY_PCB_100H
SW22: DEAD; CHERRY_PCB_125H
SW23: A; CHERRY_PCB_100H
SW24: B; CHERRY_PCB_100H
SW25: C; CHERRY_PCB_100H
SW26: D; CHERRY_PCB_100H
SW27: E; CHERRY_PCB_100H
SW28: F; CHERRY_PCB_100H
SW29: G; CHERRY_PCB_100H
SW30: H; CHERRY_PCB_100H
SW31: I; CHERRY_PCB_100H
SW32: J; CHERRY_PCB_100H
SW33: K; CHERRY_PCB_100H
SW34: L; CHERRY_PCB_100H
SW35: M; CHERRY_PCB_100H
SW36: N; CHERRY_PCB_100H
SW37: O; CHERRY_PCB_100H
SW38: P; CHERRY_PCB_100H
SW39: Q; CHERRY_PCB_100H
SW40: R; CHERRY_PCB_100H
SW41: S; CHERRY_PCB_100H
SW42: T; CHERRY_PCB_100H
SW43: U; CHERRY_PCB_100H
SW44: V; CHERRY_PCB_100H
SW45: W; CHERRY_PCB_100H
SW46: X; CHERRY_PCB_100H
SW47: Y; CHERRY_PCB_100H
SW48: Z; CHERRY_PCB_100H
SW49: SHIFT; CHERRY_PCB_225H
SW50: CTRL; CHERRY_PCB_125H
SW51: GRAPH; CHERRY_PCB_125H
SW52: CAPS_LOCK; CHERRY_PCB_175H
SW53: CODE/KANA; CHERRY_PCB_125H
SW54: F1/F6; CHERRY_PCB_100H
SW55: F2/F7; CHERRY_PCB_100H
SW56: F3/F8; CHERRY_PCB_100H
SW57: F4/F9; CHERRY_PCB_100H
SW58: F5/F10; CHERRY_PCB_100H
SW59: ESC; CHERRY_PCB_100H
SW60: TAB; CHERRY_PCB_150H
SW61: STOP; CHERRY_PCB_100H
SW62: BACK_SPACE; CHERRY_PCB_200H
SW63: SELECT; CHERRY_PCB_125H
SW64: RETURN; CHERRY_PCB_225H
SW65: SPACE; CHERRY_PCB_625H
SW66: HOME/CLS; CHERRY_PCB_100H
SW67: INSERT; CHERRY_PCB_100H
SW68: DELETE; CHERRY_PCB_100H
SW69: LEFT; CHERRY_PCB_100H
SW70: UP; CHERRY_PCB_100H
SW71: DOWN; CHERRY_PCB_100H
SW72: RIGHT; CHERRY_PCB_100H
SW73: SHIFT; CHERRY_PCB_275H
U1: 74LS145; IC_DIP16_300
U2: 74LS07; IC_DIP14_300

Connections:
/CAPS_LED: J1.12, U2.13
/CAPS_LED_BUFFERED: D2.1 (K), U2.12
/CODE: D6.2 (A), SW53.1
/COLUMN0: RN1.3 (R2), SW1.2, SW9.2, SW17.2, SW25.2, SW33.2, SW41.2, SW49.2, SW57.2, SW65.2, SW73.2, U2.5
/COLUMN0_BUF: J1.1, U2.6
/COLUMN1: J1.3, SW2.2, SW10.2, SW18.2, SW26.2, SW34.2, SW42.2, SW50.2, SW58.2, SW66.2
/COLUMN2: RN1.4 (R3), SW3.2, SW11.2, SW19.2, SW27.2, SW35.2, SW43.2, SW51.2, SW59.2, SW67.2, U2.3
/COLUMN2_BUF: J1.5, U2.4
/COLUMN3: J1.7, SW4.2, SW12.2, SW20.2, SW28.2, SW36.2, SW44.2, SW52.2, SW60.2, SW68.2
/COLUMN4: RN1.5 (R4), SW5.2, SW13.2, SW21.2, SW29.2, SW37.2, SW45.2, SW53.2, SW61.2, SW69.2, U2.1
/COLUMN4_BUF: J1.9, U2.2
/COLUMN5: J1.11, SW6.2, SW14.2, SW22.2, SW30.2, SW38.2, SW46.2, SW54.2, SW62.2, SW70.2
/COLUMN6: J1.13, SW7.2, SW15.2, SW23.2, SW31.2, SW39.2, SW47.2, SW55.2, SW63.2, SW71.2
/COLUMN7: J1.15, SW8.2, SW16.2, SW24.2, SW32.2, SW40.2, SW48.2, SW56.2, SW64.2, SW72.2
/D1+: D1.2 (A), R1.2
/D2+: D2.2 (A), R2.2
/D3+: D3.2 (A), R3.2
/GRAPH: D5.2 (A), SW51.1
/KANA_LED: J1.14, U2.11
/KANA_LED_BUFFERED: D3.1 (K), U2.10
/ROW0: SW1.1, SW2.1, SW3.1, SW4.1, SW5.1, SW6.1, SW7.1, SW8.1, U1.1 (Q0)
/ROW1: SW9.1, SW10.1, SW11.1, SW12.1, SW13.1, SW14.1, SW15.1, SW16.1, U1.2 (Q1)
/ROW2: SW17.1, SW18.1, SW19.1, SW20.1, SW21.1, SW22.1, SW23.1, SW24.1, U1.3 (Q2)
/ROW3: SW25.1, SW26.1, SW27.1, SW28.1, SW29.1, SW30.1, SW31.1, SW32.1, U1.4 (Q3)
/ROW4: SW33.1, SW34.1, SW35.1, SW36.1, SW37.1, SW38.1, SW39.1, SW40.1, U1.5 (Q4)
/ROW5: SW41.1, SW42.1, SW43.1, SW44.1, SW45.1, SW46.1, SW47.1, SW48.1, U1.6 (Q5)
/ROW6: D4.1 (K), D5.1 (K), D6.1 (K), SW50.1, SW52.1, SW54.1, SW55.1, SW56.1, U2.8
/ROW6_UNBUF: RN1.2 (R1), U1.7 (Q6), U2.9
/ROW7: SW57.1, SW58.1, SW59.1, SW60.1, SW61.1, SW62.1, SW63.1, SW64.1, U1.9 (Q7)
/ROW8: SW65.1, SW66.1, SW67.1, SW68.1, SW69.1, SW70.1, SW71.1, SW72.1, U1.10 (Q8)
/ROW_A: J1.4, U1.15 (P0)
/ROW_B: J1.6, U1.14 (P1)
/ROW_C: J1.8, U1.13 (P2)
/ROW_D: J1.10, U1.12 (P3)
/SHIFT: D4.2 (A), SW49.1, SW73.1
GND: C1.2, C2.2, C3.2, D1.1 (K), HOLE1.1, HOLE2.1, HOLE3.1, HOLE4.1, HOLE5.1, HOLE6.1, HOLE7.1, J1.16, U1.8 (GND), U2.7 (GND)
VCC: C1.1, C2.1, C3.1, J1.2, R1.1, R2.1, R3.1, RN1.1 (common), U1.16 (VCC), U2.14 (VCC)

Board: 2 copper layers, 333.4 x 124.5 mm, 96 parts (0 on the bottom side), 37 nets.

## Commit log

2019-01-18 Add BOM
2019-03-21 Keyboard: Add photo and links to schematic and PCB
2019-03-21 Add keyboard design files
2019-09-09 Mainboard: Populate KiCad and SPLD files
2019-09-10 Mainboard: Create Mainboard.md
2019-09-10 README: Add link to Keyboard.md
2019-09-10 README: Fix markdown
2019-09-11 Mainboard: Update to version 1.0
2019-09-11 Mainboard: Add Gerber files
2019-09-18 README: Update current status
2019-09-18 Keyboard: Add a known issue with missing pull up resistors
2019-09-18 Mainboard: Add top screen errata
2019-09-18 Mainboard: Swap references for R8 and R36 and values for C48 and C82
2019-09-18 Mainboard: Expand PAL Clock Gen dotted line to include U43 and C43
2019-09-18 Motherboard: Initial BOM
2019-09-18 Mainboard: BoM: Add Mouser part numbers for ICs
2019-09-19 Mainboard: BoM: Add Mouser part numbers for resistors, capacitors, and discrete semiconductors
2019-09-19 Mainboard: BoM: Add Mouser part numbers for most components
2019-09-26 Mainboard: Add slot map
2019-09-26 Fix ROM select signals
2019-09-27 Mainboard: Update slot map
2019-09-27 Mainboard: Fix ROMCS/RAMCL
2019-09-30 Mainboard: Add issues discovered during v1.0 board debug
2019-09-30 Mainboard: Fix the issues discovered so far
2019-10-01 Mainboard: Add VDP /INT pull-up missing issue
2019-10-02 Mainboard: Add compiled fuse maps for slot select SPLD
2019-10-03 Keyboard: Fix the J1 pin numbers where pull-ups should be connected
2019-10-03 Mainboard: Add cartridge orientation and SYNCIN issues
2019-10-04 README: Update the status
2019-10-04 Mainboard: Add audio related issues discovered so far
2019-10-09 Mainboard: Add SW1 and SW2 connections to the known issues
2019-10-09 Mainboard: Fixed schematic and PCB for v1.1
2019-10-09 Mainboard: Update slot_dir.pld due to schematic change
2019-10-10 Mainboard: Update BoM for v1.1
2019-10-10 Mainboard: Add joystick issue
2019-10-10 Mainboard: Add photos of v1.0 build
2019-10-10 Mainboard: Move photos to images dir
2019-10-10 Mainboard: Add introduction and specifications
2019-10-10 Mainboard: Improve I/O ports and slots sections
2019-10-14 Mainboard: Change audio filter op amp to lower-cost MCP601-I/P
2019-10-14 Mainboard: Update D1 and Q2 types
2019-10-14 Mainboard: Add changes for v1.1
2019-10-14 Mainboard: Update schematic and PCB layout with latest fixes
2019-10-14 Mainboard: Update C92-C95 capacitors
2019-10-16 Mainboard: Replace Mini DIN with regular DIN for RGB and Cassette
2019-10-16 Mainboard: Update R9 type
2019-10-16 Mainboard: Renumber capacitors
2019-10-17 Mainboard: Replace RGB and Cassette connectors with DIN8
2019-10-17 Mainboard: Renumber resistors
2019-10-17 Mainboard: Document RGB and Cassette connectors
2019-10-17 Mainboard: Document connectors
2019-10-19 Mainboard: Fix some of the issues described in #1
2019-10-19 Mainboard: Update components to match the latest schematic update
2019-10-19 Mainboard: Add changes
2019-10-19 Keyboard: Modify the pull-ups known issue
2019-10-19 Mainboard: Swap slots, use trmp cap for RTC, add color bus
2019-10-29 Mainboard: Final v1.1 design files
2019-10-30 Mainboard: Update BoM for the final v1.1 release; Update Changes
2019-10-30 Mainboard: BOM: Correct C68 - C70 part number
2019-10-30 Mainboard: Add description for connectors and jumpers
2019-10-30 Mainboard: Clarify JP1 description
2019-10-30 Mainboard: Add Table of Content
2019-10-30 Mainboard: Update Table of Content, add missing sections
2019-10-30 Mainboard: Add content to Firmware section
2019-10-30 Mainboard: Fix the SPLD URL
2019-10-30 Mainboard: The first known issue for v1.1
2019-11-06 Mainboard: Known issues: L2 and L3
2019-11-06 Mainboard: Fix Mouser project link text
2019-11-08 Mainboard: Recommend V9958 VDP
2019-11-08 Mainboard: update images for v1.1
2019-11-08 Mainboard: Add Configuration Options for NTSC/PAL and V9958/V9938
2019-11-21 README: Update introduction and status
2019-11-21 README: Minor formatting update
2019-11-27 Mainboard: It should be 7 x 1k resistors
2019-11-27 BIOS: Add make_rom.sh
2019-11-28 Building Instructions: Remove text from Micro 8088
2019-12-10 Mainboard: Fix R30 reference in video standard configuration
2019-12-17 Add troubleshooting instructions
2020-01-02 Keyboard: PCB v1.1 updates
2020-01-02 Mainboard: Update to version 1.2
2020-02-19 Mainboard: Update socket type for U47.
2020-02-19 Mainboard: Default to 600 mil socket for U47
2020-02-28 Enclosure: Add design files
2020-02-29 README: Add link to Enclosure
2020-03-22 Mainboard: Map entire 0x10000-0x1FFFF range of Flash ROM to slot 3-0
2020-03-22 BIOS: Add creating MSX2+ BIOS images. Use OpenMSX file names for BIOS ROMs
2020-03-26 BIOS: Add international keyboard patch for Japanese MSX2/MSX2+ BIOSes
2020-03-27 README: Add link to Spanish version
2020-03-27 Building instructions: Add link to Spanish version
2020-03-27 Mainboard: Add link to Spanish version
2020-03-27 Keyboard: Add link to Spanish version
2020-03-27 Enclosure: Add link to Spanish version
2020-03-27 README: Add link to English version
2020-03-27 Mainboard: Add link to English version
2020-03-27 Building instructions: Add link to English version
2020-03-27 Keyboard: Add link to English version
2020-03-27 Enclosure: Add link to English version
2020-03-28 Enclosure: Use button socket cap screws
2020-03-28 Master spanish (#10)
    * Update Enclosure_es.md
    * Update Enclosure.md
2020-03-29 Enclosure: Add slots for hex nuts in the slot guide
2020-04-14 BIOS: Use dd to patch keys
2020-04-14 BIOS: Patch backslash in Japanese font
2020-04-15 BIOS: Add international ROM version patch
2020-05-12 L2 and L3 should be 5.6uH
2020-07-01 Updated 120 ohm axial label to be "291-120-RC" to match the link and value
2020-07-01 add alternate pin strips for U3 socket
2020-07-01 Updated 120 ohm axial label to be "291-120-RC" to match the link and … (#11)
    * Updated 120 ohm axial label to be "291-120-RC" to match the link and value
    * add alternate pin strips for U3 socket
2020-07-08 add tests to make sure required ROMs are present
2020-07-09 Update omega-slot_dir.pld
    Hi,
    There is a problem in the /CS2 formula that unable 32K cartridges from running. The correct formula would be /CS2 = /A14 + A15 instead of /CS2 = /A14 + A14
2020-07-09 Update omega-slot_dir.pld (#13)
    Hi,
    There is a problem in the /CS2 formula that unable 32K cartridges from running. The correct formula would be /CS2 = /A14 + A15 instead of /CS2 = /A14 + A14
2020-07-09 Add Checking for ROM Presence (#12)
    * Updated 120 ohm axial label to be "291-120-RC" to match the link and value
    * add alternate pin strips for U3 socket
    * add tests to make sure required ROMs are present
2020-07-10 SPLDs: Update fuse maps for slot dir
2021-01-21 Add files for version 1.3eu from Jordi Solis
2021-01-21 Version 1.4: Add cut-out for the right angle slot connector. Add optional jumpers to limit memory mapper address range
2021-01-21 Mainboard: Document v1.3eu and 1.4 changes
2021-02-23 Add gerber files for motherboard v1.4
2021-07-28 Add G5V-1-DC5 as an alternate relay type
2021-07-28 Update resistors and resistor arrays parts to these available in single quantities from Mouser
2021-07-28 Update 75 ohm part name
2021-10-27 Mainboard: Clarify that Q2 is required for V9938 only
2022-01-04 Fix D1 part number
2022-01-04 Use the same D1 part as the English BOM
2022-01-04 Use the same 1N4148 part as the mainboard (tape and reel)
2022-03-10 Update F1
2023-06-28 Update README.md
    Update status
2023-06-28 Update README_es.md
    Update status
2023-06-28 Add note about replacing C93 with a wire link when using V9938 in NTSC mode
2023-08-01 Minor Fix in NTSC Video Standard Support Text
2023-08-01 Minor Fix in NTSC Video Standard Support Text (#50)
2023-10-12 Add DigiKey alternates for the DIP sockets, fix Markdown link.
    Also, add link to DigiKey trim capacitor.
2023-10-12 Add DigiKey alternates for the DIP sockets, fix Markdown link. (#51)
    Also, add link to DigiKey trim capacitor.
2024-12-15 Create Omega-Eco2_User_5mm_Higher.dxf
    Create sides 5mm higher to give added clearance to the internals for various needs.
2025-05-01 Fix issue #56, where joystick A trigger 2 was swapped with joystick B trigger 1
2025-05-01 Describe changes in v1.5, update links to schematic and PCB printouts
2025-05-01 Update links to schematic and PCB printouts
2026-02-05 Mainboard.md: BoM: Update a couple of discontinued components
2026-02-05 Mainboard_es.md: BoM: Update a couple of discontinued components
2026-02-05 Create Omega-Eco2_User_5mm_Higher.dxf (#55)
    Create sides 5mm higher to give added clearance to the internals for various needs.
2026-03-03 Keyboard: Add cache.lib file
2026-03-03 Mainboard: Add cache.lib file
